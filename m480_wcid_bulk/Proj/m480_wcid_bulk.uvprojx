# Keil uVision project m480_wcid_bulk.uvprojx, settings and files
target m480_wcid_bulk (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: m480_wcid_bulk +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\CMSIS;..\CMSIS\Include;..\StdDriver\inc;..\User\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group CMSIS
    ../CMSIS/: system_M480.c startup_M480.s
  group StdDriver
    ../StdDriver/src/: clk.c sys.c uart.c retarget.c gpio.c usbd.c
  group User
    ../User/: main.c
  group Bulk-Out
    ../User/src/: descriptors.c vendor_lbk.c
    ../User/inc/: vendor_lbk.h
